# Keil uVision project TIM_Combined.uvproj, settings and files
target TIM_Combined (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")ESEL ELITTLE FPU2
  output: TIM_Combined
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F3_Discovery;..\..\..\..\Utilities\STM32F3_Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32F3-Discovery
    ./../../../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c
    ../../../../Utilities/STM32F3_Discovery/: stm32f3_discovery_lsm303dlhc.c
  group STM32F30x_StdPeriph_Driver
    ./../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_tim.c
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_syscfg.c stm32f30x_exti.c stm32f30x_i2c.c stm32f30x_usart.c
  group User
    ./../: main.c stm32f30x_it.c system_stm32f30x.c
